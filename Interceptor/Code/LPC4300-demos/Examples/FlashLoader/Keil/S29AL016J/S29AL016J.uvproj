# Keil uVision project S29AL016J.uvproj, settings and files
target S29AL016J_TOP (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: S29AL016J_TOP
  AfterMake: cmd.exe /C copy S29AL016J_TOP.axf ..\S29AL016J_TOP.FLM
  c flags: Optim=3
  c define: TOP
  scatter file: .\Target.lin
  link misc: --entry 1
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target S29AL016J_BOT (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: S29AL016J_BOT
  AfterMake: cmd.exe /C copy S29AL016J_BOT.axf ..\S29AL016J_BOT.FLM
  c flags: Optim=3
  c define: BOTTOM
  scatter file: .\Target.lin
  link misc: --entry 1
