# Keil uVision project IPC_Blinking_M0.uvproj, settings and files
target LPC435x_IntSRAM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CM0
  AfterMake: fromelf --cadcombined --output="..\CM0_image.h" ".\Internal SRAM\CM0.axf"
  c flags: Optim=2
  c define: CORE_M0
  c include: ..\; ..\..\..\Core\CMSIS\Include; ..\..\..\Core\Device\NXP\lpc43xx\Include; ..\..\..\Drivers\include; ..\..\..\Boards
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10080000 size 0x8000
  memory RVCT9: RAM 0x10088000 size 0x2000
  group Drivers
    ../../../Drivers/source/: lpc43xx_gpio.c lpc43xx_scu.c
  group Startup
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx_M0.s
  group Source
    ../: main_m0.c
