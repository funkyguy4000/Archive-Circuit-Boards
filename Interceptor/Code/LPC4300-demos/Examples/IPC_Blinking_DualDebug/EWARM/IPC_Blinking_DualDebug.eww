<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IPC_Blinking_DualDebug_M0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IPC_Blinking_DualDebug_M4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


