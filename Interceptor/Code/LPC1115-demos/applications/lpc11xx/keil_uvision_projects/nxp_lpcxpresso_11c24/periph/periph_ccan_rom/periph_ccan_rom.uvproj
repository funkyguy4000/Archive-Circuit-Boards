# Keil uVision project periph_ccan_rom.uvproj, settings and files
target iflash_nxp_lpcxpresso_11c24 (ARM-ADS)
  device: LPC11C24/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ccan_rom_iflash_nxp_lpcxpresso_11c24
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11c24;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11cxx;..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11c24;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11cxx
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group example
    ../../../../startup_code/: sysinit.c keil_startup_lpc11xx.s
    ../../../../examples/periph/periph_ccan_rom/: ccan_rom.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_11xx/nxp_lpcxpresso_11c24/keil_output/: board_nxp_lpcxpresso_11c24.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_11xx/keil_output/chip_11cxx_lib/: chip_11cxx_lib.lib
