# IAR project periph_ccan_rom.ewp, settings and files
configuration iflash_nxp_lpcxpresso_11c24 (ARM)
  General.OGChipSelectEditMenu: LPC11C24FBD48_301 NXP LPC11C24FBD48_301
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11cxx; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11c24; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11c24; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_11xx\config_11cxx
  OBJCOPY.OOCOutputFile: periph_ccan_rom.bin
  ILINK.IlinkOutputFile: ccan_rom_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_11xx/nxp_lpcxpresso_11c24/iar_output/Exe/: board_nxp_lpcxpresso_11c24.a
    ../../../../../../software/lpc_core/lpc_chip/chip_11xx/iar_output/chip_11cxx_lib/Exe/: chip_11cxx_lib.a
  group example
    ../../../../examples/periph/periph_ccan_rom/: ccan_rom.c
    ../../../../startup_code/: iar_startup_lpc11xx.s sysinit.c
