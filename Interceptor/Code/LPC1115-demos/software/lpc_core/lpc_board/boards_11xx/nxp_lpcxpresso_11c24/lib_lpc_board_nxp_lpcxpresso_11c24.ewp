# IAR project lib_lpc_board_nxp_lpcxpresso_11c24.ewp, settings and files
configuration nxp_lpcxpresso_11c24 (ARM)
  General.OGChipSelectEditMenu: LPC11C24FBD48_301 NXP LPC11C24FBD48_301
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..; ..\..\..\lpc_chip\chip_common; ..\..\..\lpc_chip\chip_11xx; ..\..\..\lpc_chip\chip_11xx\config_11cxx; ..\..\..\lpc_board\board_common; $PROJ_DIR$; ..\..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group board_nxp_lpcxpresso_11c24
    ./: board.c board_sysinit.c
